# IAR project Backup (13) of KEA128.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: KEAZ128xxx4 Freescale KEAZ128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\USER\inc; ..\..\USER\src; ..\..\..\Libraries\startup\CoreSupport; ..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\Libraries\startup\DeviceSupport; ..\..\..\Libraries\drives\inc; ..\..\..\Libraries\seekfree; ..\..\..\Libraries\startup\DeviceSupport; D:\大学\智能车\电磁\三轮车\程序\再见队程序\调车调参版本\5.26(模糊控制转向串级9.0.3,分）\5.12(模糊控制9.0.3）\Projecct\USER; D:\大学\智能车\电磁\三轮车\程序\再见队程序\调车调参版本\5.26(模糊控制转向串级9.0.3,分）\5.12(模糊控制9.0.3）\Projecct\USER; $TOOLKIT_DIR$\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: KEA128.srec
  ILINK.IlinkOutputFile: KEA128.out
  ILINK.IlinkIcfFile: KEA128.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group drives/inc
    ../../../Libraries/drives/inc/: common.h KEA128_adc.h KEA128_flash.h KEA128_ftm.h KEA128_gpio.h KEA128_i2c.h KEA128_irq.h KEA128_kbi.h KEA128_pit.h KEA128_port.h KEA128_port_cfg.h KEA128_spi.h KEA128_systick.h KEA128_uart.h misc.h OLED.h
    ../../../Libraries/seekfree/: MPU_IIC.h
  group drives/src
    ../../../Libraries/drives/src/: common.c KEA128_adc.c KEA128_flash.c KEA128_ftm.c KEA128_gpio.c KEA128_i2c.c KEA128_irq.c KEA128_kbi.c KEA128_pit.c KEA128_port.c KEA128_spi.c KEA128_systick.c KEA128_uart.c misc.c OLED.c
    ../../../Libraries/seekfree/: MPU_IIC.c
  group seekfree
    ../../../Libraries/seekfree/: font.c font.h SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_NRF24L01.c SEEKFREE_NRF24L01.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h
  group startup
    ../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_SKEAZ1284.s
    ../../../Libraries/startup/DeviceSupport/: system_SKEAZ1284.c system_SKEAZ1284.h
  group user_c
    ../../USER/src/: AI.c debug.c direction.c fuzzy.c fuzzy2.c isr.c Kalman.c main.c Radius.c speedcontrl.c
    ../../../: keyscan.c
    ../../../Libraries/: version.txt
  group user_h
    ../../USER/inc/: AI.h debug.h direction.h fuzzy.h fuzzy2.h headfile.h isr.h Kalman.h keyscan.h Radius.h speedcontrl.h
